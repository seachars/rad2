# Keil uVision project Project.uvprojx, settings and files
target STM32_12090 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746IGKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32_12090 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F746xx,USE_IOEXPANDER,USE_USB_FS,NEW
  c misc: --C99
  c include: ../Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\Drivers\BSP\STM32F769I_EVAL;../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../Drivers/CMSIS/Include;..\Src\GdApp\include
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x20000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F7xx_HAL_Driver
    ../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_sram.c stm32f7xx_ll_fmc.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/BSP/Components
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Application/User
    ../Src/: usbd_conf.c stm32f7xx_it.c usbd_cdc_interface.c usbd_desc.c main.c stm32f7xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group User
    ../Src/: Camera.c
    ../Src/GdApp/src/: gd_app.c GD_Flash.c hw_init.c Sensor_Control.c Uart_App.c Varible.c ADS1115.c cLCD.c
  group LIB
    ../Src/GdApp/include/: Sensor.h
    ../Src/GdApp/: Sensor.lib
  group LIBUser
    ../Src/GdApp/src/: I2C.c Shutter.c SPI.c
software components: CMSIS:CORE 5.0.1
